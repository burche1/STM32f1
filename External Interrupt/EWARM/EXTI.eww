<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EXTI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\I2C\EWARM\I2C.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\SPI\EWARM\SPI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Temperature_Sensor\EWARM\temperature.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\USART\EWARM\USART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\USART synchronous\EWARM\USART synchronous.ewp</path>
    </project>
    <batchBuild />
</workspace>
