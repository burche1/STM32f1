# IAR project I2C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: $PROJ_DIR$; Debug; settings; ../; ../CMSIS; ../manual_config; ../std_periph; ../user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: settings/stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h platform_config.h startup_stm32f10x_cl.s system_stm32f10x.c system_stm32f10x.h
  group manual_config
    ../manual_config/: stm32f10x.h stm32f10x_conf.h
  group std_periph
    ../std_periph/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_usart.c stm32f10x_usart.h
